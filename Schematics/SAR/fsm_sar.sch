v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {ipin.sym} -10 -20 0 0 {name=p1 lab=VDD}
C {ipin.sym} -10 0 0 0 {name=p2 lab=VSS}
C {ipin.sym} -10 20 0 0 {name=p3 lab=clk_i}
C {ipin.sym} -10 40 0 0 {name=p4 lab=cmp_i}
C {opin.sym} 80 -20 0 0 {name=p5 lab=dac_o[0]}
C {opin.sym} 80 0 0 0 {name=p6 lab=dac_o[1]}
C {opin.sym} 80 20 0 0 {name=p7 lab=dac_o[2]}
C {opin.sym} 80 40 0 0 {name=p8 lab=dac_o[3]}
C {opin.sym} 80 60 0 0 {name=p9 lab=dac_o[4]}
C {opin.sym} 80 80 0 0 {name=p10 lab=dac_o[5]}
C {opin.sym} 80 100 0 0 {name=p11 lab=dac_o[6]}
C {opin.sym} 80 120 0 0 {name=p12 lab=dac_o[7]}
C {opin.sym} 80 140 0 0 {name=p13 lab=eoc_o}
C {opin.sym} 80 160 0 0 {name=p14 lab=result_o[0]}
C {opin.sym} 80 180 0 0 {name=p15 lab=result_o[1]}
C {opin.sym} 80 200 0 0 {name=p16 lab=result_o[2]}
C {opin.sym} 80 220 0 0 {name=p17 lab=result_o[3]}
C {opin.sym} 80 240 0 0 {name=p18 lab=result_o[4]}
C {opin.sym} 80 260 0 0 {name=p19 lab=result_o[5]}
C {opin.sym} 80 280 0 0 {name=p20 lab=result_o[6]}
C {opin.sym} 80 300 0 0 {name=p21 lab=result_o[7]}
C {ipin.sym} -10 60 0 0 {name=p22 lab=rst_i}
C {opin.sym} 80 320 0 0 {name=p23 lab=sample_o}
C {ipin.sym} -10 80 0 0 {name=p24 lab=start_i}
